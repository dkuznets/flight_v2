# Keil uVision project SOLO2_FLIGHT.uvproj, settings and files
target SOLO2 Left-wing (ARM-ADS)
  device: LPC2294/01 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: ..\Output\firmware
  BeforeMake: convert_firmware.bat "..\PLIS_fw"
  AfterMake: m.bat SOLO2_FLIGHT_LEFT
  c flags: oTime=1
  c define: THIS_DEVICE_IS_LEFT
  c include: .\CAN\inc;.\PLIS;.\FS
  asm include: .\FS\inc;.\FS\inc\interfaces;.\CAN\inc
  memory RVCT4: ROM 0x4000 size 0x3c000
  memory RVCT6: RAM 0x81000000 size 0x80000
  memory RVCT9: RAM 0x40000040 size 0x3fc0
  group Config & Wizard
    ./: Startup.s RTX_Config.c
    ./CAN/inc/: CAN_Cfg.h
    ./FS/: File_Config.c
  group Sources
    ./: main.c common.c
  group PLIS
    ./PLIS/: upload.c compress.c plis1_fw.c plis2_fw.c
  group CAN
    ./CAN/src/: CAN_LPC229x_Custom.c RTX_CAN.c RTX_CAN_EX.c
  group Devices
    ./: clock.c termostat.c termometer.c adc.c dac.c rtc_svc.c
  group Interfaces
    ./PLIS/: spi_plis.c
    ./: i2c_mc.c
  group FS
    ./FS/: SPI_LPC22xx_Custom.c FS_SPI_FlashPrg.c Retarget.c
  group Libraries (RTL)
    ./Lib/: FS_ARM_L.lib
target SOLO2 Right-wing (ARM-ADS)
  device: LPC2294/01 NXP (founded by Philips)
  cpu: as above
  output: ..\Output\firmware
  BeforeMake: convert_firmware.bat "..\PLIS_fw"
  AfterMake: m.bat SOLO2_FLIGHT_RIGHT
  c flags: oTime=1
  c include: .\CAN\inc;.\PLIS;.\FS
  asm include: .\FS\inc;.\FS\inc\interfaces;.\CAN\inc
  memory RVCT4: ROM 0x4000 size 0x3c000
  memory RVCT6: RAM 0x81000000 size 0x80000
  memory RVCT9: RAM 0x40000040 size 0x3fc0
target SOLO2 Left-wing LowGain (ARM-ADS)
  device: LPC2294/01 NXP (founded by Philips)
  cpu: as above
  output: ..\Output\firmware
  BeforeMake: convert_firmware.bat "..\PLIS_fw_low"
  AfterMake: m.bat SOLO2_FLIGHT_LEFT_LOWGAIN
  c flags: oTime=1
  c define: THIS_DEVICE_IS_LEFT
  c include: .\CAN\inc;.\PLIS;.\FS
  asm include: .\FS\inc;.\FS\inc\interfaces;.\CAN\inc
  memory RVCT4: ROM 0x4000 size 0x3c000
  memory RVCT6: RAM 0x81000000 size 0x80000
  memory RVCT9: RAM 0x40000040 size 0x3fc0
target SOLO2 Right-wing LowGain (ARM-ADS)
  device: LPC2294/01 NXP (founded by Philips)
  cpu: as above
  output: ..\Output\firmware
  BeforeMake: convert_firmware.bat "..\PLIS_fw_low"
  AfterMake: m.bat SOLO2_FLIGHT_RIGHT_LOWGAIN
  c flags: oTime=1
  c include: .\CAN\inc;.\PLIS;.\FS
  asm include: .\FS\inc;.\FS\inc\interfaces;.\CAN\inc
  memory RVCT4: ROM 0x4000 size 0x3c000
  memory RVCT6: RAM 0x81000000 size 0x80000
  memory RVCT9: RAM 0x40000040 size 0x3fc0
